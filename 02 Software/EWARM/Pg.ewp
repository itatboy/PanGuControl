# IAR project Pg.ewp, settings and files
configuration Pg (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VB ST STM32F103VB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\App\Inc; ..\Drivers\FreeRTOS\Source\CMSIS_RTOS; ..\Drivers\FreeRTOS\Source\include; ..\Drivers\FreeRTOS\Source\portable\IAR\ARM_CM3
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: Pg.hex
  ILINK.IlinkOutputFile: Pg.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User/APP
    ../App/Inc/: api.h button.h gui.h menu.h pic.h
    ../App/Src/: button.c gui.c menu.c
  group Application/User/Core
    ../Core/Src/: adc.c delay.c dma.c eeprom.c freertos.c gpio.c iic.c lcd.c main.c nrf24l01.c os.c spi.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c stm32f1xx_it.c tim.c
    ../Core/Inc/: adc.h delay.h dma.h eeprom.h gpio.h iic.h lcd.h main.h nrf24l01.h os.h spi.h tim.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/FreeRTOS
    ../Drivers/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Drivers/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Drivers/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Drivers/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
